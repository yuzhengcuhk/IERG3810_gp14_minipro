# Keil uVision project mini-pro.uvprojx, settings and files
target mini-pro (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _mini-pro +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Board;.\Core;.\Fw_lib\inc;.\User;.\Board\mini_pro_lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Fw-lib
    ./User/: stm32f10x_it.c stm32f10x_it.h
    ./Fw_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: startup_stm32f10x_hd.s core_cm3.c system_stm32f10x.c
  group Board
    ./Board/: IERG3810_Buzzer.c IERG3810_KEY.c IERG3810_LED.c IERG3810_USART_CLOKC_TREE_INIT.c IERG3810_USART1_INIT.c IERG3810_USART2_INIT.c FONT.H CFONT.H IERG3810_Buzzer.h IERG3810_KEY.h IERG3810_LED.h IERG3810_USART_CLOKC_TREE_INIT.h IERG3810_USART_PRINT.h IERG3810_USART1_INIT.h IERG3810_USART2_INIT.h IERG_Game_Logic.c IERG_Game_Logic.h IERG3810_interupt.c IERG3810_interupt.h
    ./User/: global.h
    ./Board/mini_pro_lib/: IERG3810_key_Controller.c IERG3810_key_Controller.h IERG3810_Delay.c IERG3810_Delay.h IERG3810_Game_UI.c IERG3810_Game_UI.h IERG3810_LCD_Controller.c IERG3810_LCD_Controller.h rtc.c rtc.h IERG3810_System_Init.c IERG3810_System_Init.h Tfont.h tim.c tim.h usart.c usart.h
  group User
    ./User/: main.c
